# Keil uVision project InsideHomeSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: InsideHomeSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD.h LCD.c delay.h delay.c main.c leds.c leds.h button.c button.h i2c_slave.h i2c_slave.c
